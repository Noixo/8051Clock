# Keil uVision project Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: Clock +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Documentation.txt changeLog.txt
  group header
    ./: DHT11.h ds3231.h bmp280.h eeprom.h serial.h
  group source
    ./: LCD.c main.c DHT11.c external.c timing.c i2c.c bmp280.c serial.c eeprom.c MAX7219.c ds3231.c
